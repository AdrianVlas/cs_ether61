# IAR project device_2_v_12_0_3_0(IAR 7 50 2).ewp, settings and files
configuration Flash-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..\..\working files\inc; ..\..\working files\src\modbusroutine\inc; ..\..\working files\usb; ..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\SystemView\Config; ..\..\SystemView\OS; ..\..\SystemView\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: device_2_v_12_0_3_0(IAR 7 50 2).bin
  ILINK.IlinkOutputFile: device_2_v_12_0_3_0(IAR 7 50 2).out
  ILINK.IlinkIcfFile: ..\stm32f2xx_flash.icf
  ILINK.IlinkExtraOptions: --advanced_heap
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/inc
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
  group CMSIS/src
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Linker
    ../: StackDepth.suc stm32f2xx_flash.icf stm32f2xx_flash_extsram.icf stm32f2xx_sram.icf
  group Startup
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM_Periph_Driver/inc
    ../../Libraries/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_dbgmcu.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_gpio.h stm32f2xx_i2c.h stm32f2xx_rcc.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h
  group STM_Periph_Driver/src
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group SystemView/Config
    ../../SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_NoOS.c
  group SystemView/SEGGER
    ../../SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group USB Device/Class/CDC/inc
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group USB Device/Class/CDC/src
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library/inc
    ../../Libraries/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB Device/Library/src
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver/inc
    ../../Libraries/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group USB Driver/src
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group user/inc/EEPROM_RTC
    ../../working files/inc/: const_eeprom_rtc.h
  group user/inc/FSMC
    ../../working files/inc/: const_fsmc.h
  group user/inc/general
    ../../working files/inc/: const_global.h const_septoints_interval.h const_settings.h constants.h functions_external.h functions_global.h header.h libraries.h macroses.h type_definition.h variables_external.h variables_global.h
  group user/inc/interfaces
    ../../working files/inc/: const_interfaces.h
  group user/inc/menu
    ../../working files/inc/: const_lcd_and_keyboard.h const_menu2_alarm.h const_menu2_button.h const_menu2_choose_communication_parameters.h const_menu2_choose_settings_logical_nodes.h const_menu2_configuration.h const_menu2_diagnostyka.h const_menu2_editor_logical_nodes.h const_menu2_fix_block.h const_menu2_group_alarm.h const_menu2_info.h const_menu2_input.h const_menu2_input_GOOSE_block.h const_menu2_input_MMS_block.h const_menu2_labels.h const_menu2_list_settings.h const_menu2_list_settings_param.h const_menu2_log.h const_menu2_main.h const_menu2_meander.h const_menu2_measurement.h const_menu2_network_output_block.h const_menu2_output_led.h const_menu2_password.h const_menu2_registrators.h const_menu2_setting_language.h const_menu2_standard_logic.h const_menu2_state_inputs_outputs.h const_menu2_time.h const_menu2_timer.h const_menu2_trigger.h const_menu2_ts.h const_menu2_tu.h const_menu_ver2.h strings_external.h strings_global.h
  group user/inc/microcontriller
    ../../working files/inc/: hw_config.h platform_config.h stm32f2xx_conf.h stm32f2xx_it.h
  group user/inc/MO
    ../../working files/inc/: const_MO.h
  group user/inc/protection
    ../../working files/inc/: const_df.h const_global_timers.h const_koef_povernennja.h const_measurement.h const_watchdog.h
  group user/inc/Serial Dataflash
    ../../working files/inc/: const_driver_serial_dataflash.h
  group user/src/EEPROM_RTC
    ../../working files/src/: eeprom_rtc.c
  group user/src/FSMC
    ../../working files/src/: fsmc_sram.c
  group user/src/general
    ../../working files/v_A_shm/: low_level_init.c
    ../../working files/src/: main.c procedures.c start_settings.c
  group user/src/interfaces
    ../../working files/src/: interfaces.c
  group user/src/interfaces/modbusroutine
    ../../working files/src/modbusroutine/component/: RegProBigComponent.c
    ../../working files/src/modbusroutine/: start_settings_m.c supervisor.c
  group user/src/interfaces/modbusroutine/component
    ../../working files/src/modbusroutine/component/: AISmallComponent.c ANDBigComponent.c CGSBigComponent.c CommonBigComponent.c CommonSmallComponent.c ConfigBigComponent.c DOUTBigComponent.c DOUTSmallComponent.c DTRBigComponent.c DVBigComponent.c DVSmallComponent.c GIBigComponent.c IGOOSEBigComponent.c IMMSBigComponent.c IUSmallComponent.c KEYSmallComponent.c MEBigComponent.c MFTBigComponent.c NOTBigComponent.c OLANBigComponent.c ORBigComponent.c PKVBigComponent.c ResursBigComponent.c RMTKeySmallComponent.c RPRBigComponent.c RPRSmallComponent.c SDIBigComponent.c SDISmallComponent.c SZSBigComponent.c T1SmallComponent.c T2SmallComponent.c TSBigComponent.c TSSmallComponent.c TUBigComponent.c TUSmallComponent.c XORBigComponent.c YustBigComponent.c
  group user/src/interfaces/modbusroutine/inc
    ../../working files/src/modbusroutine/inc/: componentdef.h componentenum.h prototyps.h variables_external_m.h variables_global_m.h
  group user/src/interrupts
    ../../working files/src/: interrupts.c
  group user/src/menu
    ../../working files/src/: driver_lcd.c menu_alarm.c menu_choose_communication_parameters.c menu_choose_settings_logical_nodes.c menu_configuration.c menu_diagnostyka.c menu_editor_logical_nodes.c menu_group_alarm.c menu_info.c menu_input.c menu_labels.c menu_level_password.c menu_list_logical_nodes.c menu_list_settings.c menu_list_settings_param.c menu_main.c menu_meander.c menu_output_led.c menu_registrators.c menu_setting_language.c menu_state_inputs_outputs.c menu_time.c menu_timer.c menu_ver2.c menu_view_measurement.c
  group user/src/microcontroller
    ../../working files/src/: hw_config.c stm32f2xx_it.c
  group user/src/MO
    ../../working files/src/: mo.c
  group user/src/protection
    ../../working files/src/: measurement.c protections.c
  group user/src/Serial Dataflash
    ../../working files/src/: driver_serial_dataflash.c
  group user/usb/inc
    ../../working files/usb/: usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
  group user/usb/src
    ../../working files/usb/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group user/v_A_shm
    ../../working files/v_A_shm/: andstng.h BaseInPoint.cpp BaseInPoint.h CLUTs.cpp ExtPoint.cpp FixBlWrp.cpp InPoint.cpp LUAlt.cpp LUAnd_8_1.cpp LUBase.cpp LUBase.h LUBGS.cpp LUDInput_0_1.cpp LUDout_1_0.cpp LUDout_1_0.h LUFKey.cpp LUGoos.cpp LULan.cpp LULed.cpp LULog.cpp LULss.cpp LUMms.cpp LUNot_1_1.cpp LUOr_8_1.cpp LUTestLed.cpp LUTrig.cpp LUTu.cpp LUXor_8_1.cpp MALed.cpp Mft.cpp prtTmr.hpp RunErLed.cpp Schem_O.cpp Shematic.cpp Shematic.h StatInfo.cpp
  group user/v_A_shm/v_A_shm_C
    ../../working files/v_A_shm/: I_Shm.c prtTmr.c Tim3.c
